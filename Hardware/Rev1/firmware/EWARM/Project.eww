<?xml version="1.0" encoding="UTF-8"?>
<workspace>
  <project>
    <path>$WS_DIR$\defogger_and_wiper.ewp</path>
  </project>
  <batchBuild />
</workspace>
